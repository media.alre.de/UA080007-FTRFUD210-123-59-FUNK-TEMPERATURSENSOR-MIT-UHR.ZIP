Properties of the parts of a building model (IFC4)

# File
Description: Funk-Raumtemperatursensor mit Uhr, UP, Abdeckung 55 x 55 mm, verkehrs-/studioweiß, glänzend, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: UA080007, Funk-Raumtemperatursensor mit Uhr, UP, Abdeckung 55 x 55 mm, verkehrs-/studioweiß, glänzend
In: Raum
Description: Funk-Sensoren für in Wohn-, Büro- und Hotelräumen üblichen Verschmutzungsgrad. Anwendung überwiegend im Sanierungsbereich oder bei Heizungsanlagenerweiterungen. UP-Funk-Raumtemperatursensor zur Erfassung und Einstellung der Raumtemperatur mit Uhr. In Verwendung mit alre-Funk-Aktoren wird eine zeitgesteuerte Einzelraum-Temperaturregelung verwirklicht.; Classification: EC001101 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: UA080007; ModelLabel: FTRFUd210.123#59; GlobalTradeItemNumber: 4050528068910; ProductURL: https://alre.de/produkt_UA080007
Pset_Specification - NominalLength: 0.071 m; NominalWidth: 0.071 m; NominalDepth: 0.046 m; NetWeight: 0.149
Pset_ALRE_ETIM_Properties - Montageart: Unterputz; Zusammenstellung: Basiselement mit Komplettgehäuse; Farbe: weiß; Oberflächenschutz: lackiert; Mit Display: yes; Werkstoffgüte: Thermoplast; Bussystem Funkbus: yes; Mit Busankopplung: no; Anzahl der digitalen Eingänge: 0; Werkstoff: Kunststoff; Mit Diebstahl-/Demontageschutz: yes; Parallel-Betrieb möglich: yes; RAL-Nummer (ähnlich): 9010; Schutzart (IP): IP30; Mit LED-Anzeige: no; Transparent: no; Ausführung der Oberfläche: glänzend; Mit Vor-Ort Bedienung: yes; Funk bidirektional: yes; Bussystem KNX Secure: no; Bussystem KNX Secure-RF (Funk): no; ETIM-Klasse: EC001101; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-UA080007.pdf
